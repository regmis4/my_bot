Commit message: Adding Lidar

File: description/robot_core.xacro (robot description, xacro)
@@ -13,4 +13,7 @@
 <material name="black">
         <color rgba= "0 0 0 0" />
+    </material>
+<material name="red">
+        <color rgba= "1 0 0 1" />
     </material>
  <!-- BASE LINK-->
